# Keil uVision project DustNoise_Monitor.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RF STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0xC0000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DustNoise_Monitor +hex
  AfterMake: D:\Keil_v5_V5.27\ARM\ARMCLANG\bin\fromelf.exe  --bin -o  ..\OBJ\DustNoise_Monitor.bin ..\OBJ\DustNoise_Monitor.axf
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\STM32F10x_FWLib\inc;..\FWLIB\STM32F10x_FWLib\inc;..\UCOSII\CORE;..\UCOSII\CONFIG;..\UCOSII\PORT;..\FATFS\exfuns;..\FATFS\src\option;..\FATFS\src;..\MALLOC;..\HARDWARE\485;..\HARDWARE\DTU;..\HARDWARE\GT21L162S2W;..\HARDWARE\Init_IO;..\HARDWARE\LED_SCREEN;..\HARDWARE\RTC;..\HARDWARE\SD;..\HARDWARE\SENSOR;..\HARDWARE\SPI;..\HARDWARE\STMFLASH;..\HARDWARE\TIMER;..\HARDWARE\USART;..\HARDWARE\WDG;..\HARDWARE\LINK_LIST
  memory RVCT4: ROM 0x8010000 size 0xb0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/rtc/: rtc.c
    ../HARDWARE/dtu/: dtu.c
    ../HARDWARE/wdg/: wdg.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/stmflash/: stmflash.c
    ../HARDWARE/485/: modbus_host.c
    ../HARDWARE/Init_IO/: Init_IO.c
    ../HARDWARE/USART/: usart2.c uart4.c usart5.c
    ../HARDWARE/GT21L162S2W/: GT21L16S2W.c
    ../HARDWARE/SENSOR/: SENSOR.c
    ../HARDWARE/LED_SCREEN/: LED_MATRIX.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LINK_LIST/: link_list.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_spi.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: mycc936.c
  group MALLOC
    ../MALLOC/: malloc.c
